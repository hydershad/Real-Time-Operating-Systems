# Keil uVision project PeriodicTimer0AInts.uvproj, settings and files
target PeriodicTimer0AInts (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: PeriodicTimer0AInts
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c cr4_fft_64_stm32.s PID_stm32.s lab2.c interpreter.c FIFO.c ST7735.c ADC.c OS.c UART.c SysTickInts.c Timer2.c Timer2.h OS_asm.s eDisk.c efile.c SD_test.c
